# Keil uVision project IFRecDevice.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F338 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: IFRecDevice
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
